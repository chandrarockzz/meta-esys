FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
 
SRC_URI += "file://0001-Initial-change-Changed-the-board-name-to-ESYS.patch"
